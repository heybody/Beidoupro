# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32GG380F1024 EnergyMicro EFM32GG380F1024
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\App\; ..\App\CPU\; ..\App\OS\; ..\App\Protocol\; ..\BSP\; ..\CPU\Core\ARM-Cortex-M3\; ..\CPU\DriverLib\EnergyMicro\EFM32GG\inc\; ..\CPU\DriverLib\EnergyMicro\EFM32GG\src\; ..\CPU\DriverLib\EnergyMicro\EFM32GG\lib\; ..\CPU\Devices\EnergyMicro\EFM32GG\; ..\uCOS-II\Ports\; ..\uCOS-II\Source\; ..\Library\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project_0x00020000.hex
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: EFM32GG380F1024.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ../App/: app.h esealbd.c esealbd.h gnss.c gnss.h gprs_ublox.c gprs_ublox.h main.c rf.c rf.h ringbuf.c sensor.c sensor.h
    ../App/Protocol/: online.c
  group App/CPU
    ../App/CPU/: cpu_cfg.h
  group App/OS
    ../App/OS/: app_cfg.h includes.h os_cfg.h os_hook.c os_hook.h
  group App/Protocol
    ../App/Protocol/: esealbd_gprs.c esealbd_gprs.h esealbd_offline.c esealbd_offline.h esealbd_operation.c esealbd_operation.h esealbd_sensor.c esealbd_sensor.h esealbd_updata.c esealbd_updata.h online.h
  group BSP
    ../BSP/: bsp.h bsp_a7153.c bsp_a7153.h bsp_a7153_reg.h bsp_bdcom.c bsp_bdcom.h bsp_ble.c bsp_ble.h bsp_chip.h bsp_com.c bsp_com.h bsp_hm1103c.c bsp_hm1103c.h bsp_inmarsat.c bsp_inmarsat.h bsp_key.c bsp_key.h bsp_led.c bsp_led.h bsp_mg2639.c bsp_mg2639.h bsp_mma8491.c bsp_mma8491.h bsp_ublox.c bsp_ublox.h
  group CPU/Core/ARM-Cortex-M3
    ../CPU/Core/ARM-Cortex-M3/: cm3.c cm3.h cpu.c cpu.h interrupt.c interrupt.h startup_ewarm.c
  group CPU/Devices/EnergyMicro/EFM32GG
    ../CPU/Devices/EnergyMicro/EFM32GG/: dev.c dev.h dev_clock.c dev_clock.h dev_flash.c dev_flash.h dev_gpio.c dev_gpio.h dev_i2c.c dev_i2c.h dev_sleep.c dev_sleep.h dev_spi.c dev_spi.h dev_uart.c dev_uart.h dev_wdog.c dev_wdog.h
  group CPU/DriverLib/EnergyMicro/EFM32GG/inc
    ../CPU/DriverLib/EnergyMicro/EFM32GG/inc/: cmu.h devinfo.h emu.h gpio.h i2c.h leuart.h msc.h romtable.h uart.h usart.h wdog.h
  group CPU/DriverLib/EnergyMicro/EFM32GG/lib
    ../CPU/DriverLib/EnergyMicro/EFM32GG/lib/: efm32.h efm32_gg.h
  group CPU/DriverLib/EnergyMicro/EFM32GG/src
    ../CPU/DriverLib/EnergyMicro/EFM32GG/src/: cmu.c devinfo.c emu.c gpio.c i2c.c leuart.c msc.c romtable.c uart.c usart.c wdog.c
  group Library
    ../Library/: crc.c crc.h encrypt.c encrypt.h fifo.c fifo.h head.c head.h queue.c queue.h sha1.c sha1.h socket.c socket.h utc.c utc.h util.c util.h
  group uC/OS-II/Ports
    ../uCOS-II/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uC/OS-II/Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
